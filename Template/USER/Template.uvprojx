# Keil uVision project Template.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\BSP\Inc;..\USMART;..\Fatfs\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\AUDIOCODEC\wav;..\APP;..\APP\Encode_Check_Func;..\APP\Speech_Play;..\APP\Speech_Rec
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c includes.h FreeRTOSConfig.h
  group BSP
    ./: bsp.h bsp.c
    ../BSP/Src/: bsp_led.c bsp_sdio_sdcard.c bsp_wm8978.c bsp_myiic.c bsp_i2s.c bsp_key.c bsp_exti.c bsp_dma.c bsp_usart.c bsp_spi.c JLX_GB2312G_1016.c JLX_GB2312z.c bsp_swi2c.c bsp_pcf8574.c bsp_encoder.c bsp_dhtxx.c bsp_bh1750fvi.c
  group APP
    ../AUDIOCODEC/wav/: wavplay.c
    ../APP/: myapp.c
    ../APP/Speech_Rec/: Speech_Rec.c Voice_Access.c
    ../APP/Speech_Play/: audioplay.c
    ../APP/Encode_Check_Func/: base64.c CRC.c gbk2utf2uni.c GBK.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOD/Ports
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group FATFS
    ../Fatfs/inc/: ffconf.h
    ../Fatfs/src/: diskio.c ff.c ffsystem.c ffunicode.c exfuns.c fattester.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
    ./: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_spi.c
  group SEGGER/HardFault
    ./segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group README
    ../: readme.txt
